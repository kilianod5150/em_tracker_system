# Keil uVision project Project.uvprojx, settings and files
target STM32F7-DISCO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F7-DISCO +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F756xx,USE_HAL_DRIVER,USE_STM32746G_DISCOVERY
  c misc: --C99
  c include: ../STemWin_Addons;../Config;../Core/inc;../STemWin_Addons;../Modules/vnc_server;../../../../Utilities/CPU;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32746G-Discovery;../../../../Drivers/BSP/Components;../../../../Drivers/BSP/Components/Common;../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../../../Middlewares/Third_Party/LwIP/src/include/                                                      ;../../../../Middlewares/Third_Party/LwIP/system;../../../../Middlewares/Third_Party/LwIP/system/OS;../../../../Middlewares/ST/STemWin/inc;../../../../Middlewares/Third_Party/FatFs/src;../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Modules/audio_player/Addons/SpiritDSP_Equalizer;../Modules/audio_player/Addons/SpiritDSP_LoudnessControl
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x3c000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: STM32F7-DISCO\STM32F7-DISCO.sct
  link misc: --diag_suppress=L6329
  group Application/User/Core
    ../Core/Src/: k_storage.c k_module.c k_rtc.c k_menu.c stm32f7xx_it.c stm32f7xx_hal_timebase_tim.c k_startup.c main.c k_bsp.c
  group Middlewares/USBH_Library/Class/MSC
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc.c usbh_msc_bot.c
  group Application/User/Modules/audio_recorder
    ../Modules/audio_recorder/: audio_recorder_win.c audio_recorder_app.c
  group Middlewares/USBH_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_pipes.c usbh_core.c usbh_ctlreq.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
  group Drivers/STM32F4xx_HAL_Drivers
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_crc_ex.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_sram.c stm32f7xx_hal_sdram.c stm32f7xx_hal_gpio.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_adc.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_pcd.c stm32f7xx_hal_lptim.c stm32f7xx_hal_rcc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_pwr.c stm32f7xx_hal_spi.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_usb.c stm32f7xx_hal.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_rng.c stm32f7xx_hal_uart.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_flash.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_cec.c stm32f7xx_hal_crc.c stm32f7xx_hal_usart.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_dac.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_qspi.c stm32f7xx_hal_iwdg.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_nor.c stm32f7xx_hal_rtc.c stm32f7xx_hal_tim.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_irda.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_hash.c stm32f7xx_hal_dma.c
  group Application/User/Modules/VideoPlayer
    ../Modules/videoplayer/: video_player_win.c
  group Middlewares/LwIP/Netif
    ../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
    ../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/FreeRTOS
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c event_groups.c croutine.c tasks.c timers.c
  group Application/User/Modules/Audio/Addons
    ../Modules/audio_player/Addons/SpiritDSP_Equalizer/: lib_equalizer_cortex_m4.a
    ../Modules/audio_player/Addons/SpiritDSP_LoudnessControl/: lib_loudness_cortex_m4.a
  group Middlewares/LwIP/Core
    ../../../../Middlewares/Third_Party/LwIP/src/core/: raw.c tcp_out.c sys.c netif.c pbuf.c memp.c init.c stats.c inet_chksum.c tcp_in.c mem.c udp.c lwip_timers.c tcp.c def.c dns.c
  group Drivers/BSP/Component
    ../../../../Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Application/User/Modules/home_alarm
    ../Modules/home_alarme/: home_alarm_win.c
  group Drivers/BSP/STM32746G_DISCO
    ../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery_audio.c stm32746g_discovery.c stm32746g_discovery_qspi.c stm32746g_discovery_ts.c stm32746g_discovery_sdram.c
  group Application/User/Modules/gardening_control
    ../Modules/gardening_control/: gardening_control_win.c
  group Middlewares/LwIP/Api
    ../../../../Middlewares/Third_Party/LwIP/src/api/: netbuf.c sockets.c tcpip.c api_lib.c pppapi.c err.c netdb.c api_msg.c netifapi.c
  group Application/User/Modules/Common
    ../Modules/Common/: audio_if.c
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group Middlewares/STemWin/ST_GUI_Addons
    ../STemWin_Addons/: STM32746G_Discovery_STemWin_Addons_Keil.lib
  group Application/User/Modules/vnc_server
    ../Modules/vnc_server/: vnc_app.c vnc_server_win.c ethernetif.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Application/User/Modules/sys_info
    ../Modules/settings/: settings_win.c
  group Application/User/Utilities
    ../../../../Utilities/CPU/: cpu_utils.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c icmp.c ip4.c dhcp.c ip_frag.c ip4_addr.c igmp.c
  group Application/User/Modules/games
    ../Modules/games/: games_win.c
  group Middlewares/FreeRTOS/Portable
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/STemWin/OS
    ../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/USBH_Library/Config
    ../Config/: usbh_conf.c
  group Application/User/Modules/Audio
    ../Modules/audio_player/: audio_player_win.c audio_player_app.c
  group Middlewares/STemWin/Config
    ../Config/: LCDConf.c GUIConf.c
  group Middlewares/FatFs/Options
    ../../../../Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group Middlewares/STemWin/Library
    ../../../../Middlewares/ST/STemWin/Lib/: STemWin528_CM7_OS_Keil_ot.lib
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
