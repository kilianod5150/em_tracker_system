# Keil uVision project Project.uvprojx, settings and files
target STM32F746ZG_Nucleo (ARM-ADS)
  device: STM32F746ZGTx STMicroelectronics
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F746ZG_Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32F7XX_NUCLEO_144
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../Drivers/STM32F7xx_HAL_Driver/Inc
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sram.c stm32f7xx_hal_dac.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_nor.c stm32f7xx_hal_dma.c stm32f7xx_ll_usb.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_sai.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_cec.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_nand.c stm32f7xx_hal_wwdg.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_cryp.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_ll_fmc.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rng.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_rcc.c stm32f7xx_hal_can.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_cortex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_irda.c stm32f7xx_hal_sdram.c stm32f7xx_hal_pwr.c stm32f7xx_hal.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_crc.c stm32f7xx_hal_pcd.c stm32f7xx_hal_gpio.c stm32f7xx_hal_adc.c stm32f7xx_hal_i2s.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_lptim.c stm32f7xx_hal_flash.c
  group Example/User
    ../Src/: stm32f7xx_hal_msp.c main.c stm32f7xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32f746xx.s
software components: CMSIS:CORE 4.3.0
